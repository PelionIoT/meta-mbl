# Copyright (c) 2019 Arm Limited and Contributors. All rights reserved.
#
# SPDX-License-Identifier: MIT

# Disable systemd integration.
SYSTEMD_AUTO_ENABLE = "disable"
