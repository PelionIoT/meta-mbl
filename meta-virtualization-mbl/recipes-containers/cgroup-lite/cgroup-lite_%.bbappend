# Copyright (c) 2019 Arm Limited and Contributors. All rights reserved.
#
# SPDX-License-Identifier: MIT

SYSTEMD_AUTO_ENABLE_${PN} = "disable"
