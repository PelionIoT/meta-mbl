inherit setuptools3
require python-scipy.inc