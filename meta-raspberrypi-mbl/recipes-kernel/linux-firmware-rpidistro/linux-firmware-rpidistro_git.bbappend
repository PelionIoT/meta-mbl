# Copyright (c) 2019 Arm Limited and Contributors. All rights reserved.
#
# SPDX-License-Identifier: MIT

# Point to the commit: Revert "Add latest Cypress WiFi firmware (May 2019)"
SRCREV = "00daf85ffa373ecce7836df7543c6ebe4cf43639"
