# Copyright (c) 2019 Arm Limited and Contributors. All rights reserved.
#
# SPDX-License-Identifier: MIT

SRCREV = "db2e367bfc3b119609f837eb973d915f6c550b2f"
