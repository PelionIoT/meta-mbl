# Copyright (c) 2018 Arm Limited and Contributors. All rights reserved.
#
# SPDX-License-Identifier: MIT

do_deploy[depends] += " atf-rpi3:do_deploy"
