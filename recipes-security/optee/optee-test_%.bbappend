SRCREV="45218eb59b006ad20cc7610904f291dd85157a43"
SRCREV_bananapi-zero="294ffbd5263cf4304a1c6564d09857062ed87243"
SRCREV_raspberrypi3="950ea1cda6d31a3c63918deba5f3e6d0938cb547"
