# This is just a workaround for bug:
# https://bugzilla.yoctoproject.org/show_bug.cgi?id=12616

HOMEPAGE = "https://github.com/fsnotify/fsnotify"
PKG_NAME = "github.com/fsnotify/${SRCNAME}"