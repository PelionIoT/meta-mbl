# Copyright (c) 2019 Arm Limited and Contributors. All rights reserved.
#
# SPDX-License-Identifier: MIT

inherit devicetree

SRC_URI = "file://*.dts"

LICENSE = "BSD-3-Clause"

COMPATIBLE_MACHINE = "raspberrypi3-mbl"

LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/BSD-3-Clause;md5=550794465ba0ec5312d6919e203a55f9"
