# This is just a workaround for bug:
# https://bugzilla.yoctoproject.org/show_bug.cgi?id=12575

do_make_scripts() {
}
