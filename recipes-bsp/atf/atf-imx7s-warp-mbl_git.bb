# Copyright (c) 2018 Arm Limited and Contributors. All rights reserved.
#
# SPDX-License-Identifier: MIT

require atf-imx7-mbl_git.inc

PLATFORM = "warp7"
