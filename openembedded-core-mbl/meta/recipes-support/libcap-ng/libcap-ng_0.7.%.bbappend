# Copyright (c) 2019 Arm Limited and Contributors. All rights reserved.
#
# SPDX-License-Identifier: MIT

EXTRA_OEMAKE = "LDFLAGS=-pthread"
