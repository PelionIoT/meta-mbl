# Copyright (c) 2018 Arm Limited and Contributors. All rights reserved.
#
# SPDX-License-Identifier: MIT

SUMMARY = "Temporary Recipe for OpenMAX IL plugins for GStreamer Until meta-raspberrypi is unpinned"
LICENSE = "LGPLv2.1"

