SRCREV = "224318f95f9e41f916579a20f3275ff3773f9c94"
SRC_URI = "git://git@github.com/ARMmbed/mbl-u-boot.git;protocol=ssh;nobranch=1"
